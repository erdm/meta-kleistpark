require linux-fusion.inc

PR = "${INC_PR}.0"

SRCREV = "2e49e4174311a0f9e380de6d5fb0982ddd5b2bf9"